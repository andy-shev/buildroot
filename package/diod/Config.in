## package/diod/Config.in
```kconfig
config BR2_PACKAGE_DIOD
        bool "diod"
        help
	  Distributed I/O Daemon - A 9P file server.

	  https://github.com/chaos/diod
```
